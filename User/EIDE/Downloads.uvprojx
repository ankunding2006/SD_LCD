# Keil uVision project Downloads.uvprojx, settings and files
target Downloads (ARM-ADS)
  device: ARMCM4 ARM
  output: Downloads
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\FATFS\Target;..\..\FATFS\App;..\..\Core\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Middlewares\Third_Party\FatFs\src;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\sfud\inc;..\..\Middlewares\littleFS\inc;..\BSP\LCD_ST7789;..\emm_v5;..\LineDetect;..\my_menu;..\my_menu\app;..\my_menu\cot_menu-v1.3.0;..\task;..\USMART;..\USMART\SYSTEM\delay;..\USMART\SYSTEM\sys;..\USMART\SYSTEM\usart;.cmsis\include;..\..\MDK-ARM\RTE\_Downloads;..\car_config
  asm define: USE_HAL_DRIVER,STM32F407xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Middlewares/sfud
    ../../Middlewares/sfud/src/: sfud.c sfud_sfdp.c
    ../../Middlewares/sfud/port/: sfud_port.c
  group Middlewares/littleFS
    ../../Middlewares/littleFS/: lfs.c lfs_port.c lfs_util.c
  group Middlewares/Third_Party
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usart.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group FATFS
    ../../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
    ../../FATFS/App/: fatfs.c
  group User/USMART
    ../USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
    ../USMART/SYSTEM/sys/: sys.c
    ../USMART/SYSTEM/delay/: delay.c
    ../USMART/SYSTEM/usart/: user_usart.c
  group User/task
    ../task/: control.c task.c test.c
  group User/my_menu
    ../my_menu/cot_menu-v1.3.0/: cot_menu.c
    ../my_menu/app/: my_menu.c
  group User/LineDetect
    ../LineDetect/: gray_detection.c nchd12.c soft_i2c.c
  group User/emm_v5
    ../emm_v5/: Emm_V5.c
  group User/BSP
    ../BSP/LCD_ST7789/: lcd_core.c lcd_font.c lcd_port.c
  group Core
    ../../Core/Src/: LED.c main.c gpio.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group MDK-ARM
    ../../MDK-ARM/: startup_stm32f407xx.s
