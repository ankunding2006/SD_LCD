# Keil uVision project Downloads.uvprojx, settings and files
target Downloads (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Downloads +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../FATFS/Target;../FATFS/App;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/LCD_ST7789;../Middlewares/USMART;../Middlewares/USMART/SYSTEM/usart;../Middlewares/USMART/SYSTEM/sys;../Middlewares/USMART/SYSTEM/delay;../Middlewares/USMART/USMART;../Middlewares/lvgl_Library;../Middlewares/lvgl_Library/src;../Middlewares/lvgl_Library/examples/porting
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: LED.c main.c gpio.c sdio.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usart.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group LCD
    ../Drivers/BSP/LCD_ST7789/: lcd.h lcd_core.c lcd_font.c lcd_font.h lcd_port.c lcd_port.h picture.h
  group USMART
    ../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
    ../Middlewares/USMART/SYSTEM/delay/: delay.c
    ../Middlewares/USMART/SYSTEM/sys/: sys.c
    ../Middlewares/USMART/SYSTEM/usart/: usart.c
  group LVGL_src
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_refr_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/display/: lv_display.c lv_display.h lv_display_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d.h lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_mask_private.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx.h lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_utils.h lv_nema_gfx_path.c lv_nema_gfx_path.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d.h lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_buf_map.h lv_g2d_utils.c lv_g2d_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_cfg.h lv_pxp_osa.c lv_pxp_osa.h lv_pxp_utils.c lv_pxp_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_buf.h lv_vglite_matrix.c lv_vglite_matrix.h lv_vglite_path.c lv_vglite_path.h lv_vglite_utils.c lv_vglite_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/opengles/: lv_draw_opengles.c lv_draw_opengles.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d.h lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/blend/arm2d/: lv_blend_arm2d.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/blend/helium/: lv_blend_helium.h lv_blend_helium.S
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/blend/neon/: lv_blend_neon.h lv_blend_neon.S
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite.h lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_type.h lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_decoder.h lv_vg_lite_grad.c lv_vg_lite_grad.h lv_vg_lite_math.c lv_vg_lite_math.h lv_vg_lite_path.c lv_vg_lite_path.h lv_vg_lite_pending.c lv_vg_lite_pending.h lv_vg_lite_stroke.c lv_vg_lite_stroke.h lv_vg_lite_utils.c lv_vg_lite_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c lv_renesas_glcdc.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/st_ltdc/: lv_st_ltdc.c lv_st_ltdc.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/display/tft_espi/: lv_tft_espi.cpp lv_tft_espi.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/evdev/: lv_evdev.c lv_evdev.h lv_evdev_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/glfw/: lv_glfw_window.c lv_glfw_window.h lv_glfw_window_private.h lv_opengles_debug.c lv_opengles_debug.h lv_opengles_driver.c lv_opengles_driver.h lv_opengles_texture.c lv_opengles_texture.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/libinput/: lv_libinput.c lv_libinput.h lv_libinput_private.h lv_xkb.c lv_xkb.h lv_xkb_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/: lv_drivers.h README.md
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_cache.h lv_nuttx_entry.c lv_nuttx_entry.h lv_nuttx_fbdev.c lv_nuttx_fbdev.h lv_nuttx_image_cache.c lv_nuttx_image_cache.h lv_nuttx_lcd.c lv_nuttx_lcd.h lv_nuttx_libuv.c lv_nuttx_libuv.h lv_nuttx_profiler.c lv_nuttx_profiler.h lv_nuttx_touchscreen.c lv_nuttx_touchscreen.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/qnx/: lv_qnx.c lv_qnx.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_keyboard.h lv_sdl_mouse.c lv_sdl_mouse.h lv_sdl_mousewheel.c lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_window.c lv_sdl_window.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/uefi/: lv_uefi.h lv_uefi_context.c lv_uefi_context.h lv_uefi_display.c lv_uefi_display.h lv_uefi_edk2.h lv_uefi_gnu_efi.h lv_uefi_indev.h lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c lv_uefi_private.h lv_uefi_std_wrapper.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/wayland/: lv_wayland.c lv_wayland.h lv_wayland_smm.c lv_wayland_smm.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/windows/: lv_windows_context.c lv_windows_context.h lv_windows_display.c lv_windows_display.h lv_windows_input.c lv_windows_input.h lv_windows_input_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/drivers/x11/: lv_x11.h lv_x11_display.c lv_x11_input.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/font/: lv_binfont_loader.c lv_binfont_loader.h lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/indev/: lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/layouts/flex/: lv_flex.c lv_flex.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/layouts/grid/: lv_grid.c lv_grid.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/barcode/: code128.c code128.h LICENSE.txt lv_barcode.c lv_barcode.h lv_barcode_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/bmp/: lv_bmp.c lv_bmp.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/expat/: add_lvgl_if.sh ascii.h asciitab.h expat.h expat_config.h expat_external.h iasciitab.h internal.h latin1tab.h LICENSE.txt nametab.h siphash.h utf8tab.h winconfig.h xmlparse.c xmlrole.c xmlrole.h xmltok.c xmltok.h xmltok_impl.c xmltok_impl.h xmltok_ns.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/freetype/: arial.ttf ftmodule.h ftoption.h LICENSE.txt lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fsdrv.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/gif/: gifdec.c gifdec.h gifdec_mve.h LICENSE.txt lv_gif.c lv_gif.h lv_gif_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/libpng/: lv_libpng.c lv_libpng.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/lodepng/: LICENSE.txt lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/lz4/: LICENSE.txt lz4.c lz4.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/qrcode/: LICENSE.txt lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/rle/: lv_rle.c lv_rle.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/svg/: lv_svg.c lv_svg.h lv_svg_decoder.c lv_svg_decoder.h lv_svg_parser.c lv_svg_parser.h lv_svg_render.c lv_svg_render.h lv_svg_token.c lv_svg_token.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/thorvg/: add_lvgl_if.sh config.h LICENSE.txt thorvg.h thorvg_capi.h thorvg_lottie.h tvgAccessor.cpp tvgAnimation.cpp tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.cpp tvgCanvas.h tvgCapi.cpp tvgCommon.h tvgCompressor.cpp tvgCompressor.h tvgFill.cpp tvgFill.h tvgFrameModule.h tvgGlCanvas.cpp tvgInitializer.cpp tvgInlist.h tvgIteratorAccessor.h tvgLoader.cpp tvgLoader.h tvgLoadModule.h tvgLock.h tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieBuilder.h tvgLottieCommon.h tvgLottieExpressions.cpp tvgLottieExpressions.h tvgLottieInterpolator.cpp tvgLottieInterpolator.h tvgLottieLoader.cpp tvgLottieLoader.h tvgLottieModel.cpp tvgLottieModel.h tvgLottieModifier.cpp tvgLottieModifier.h tvgLottieParser.cpp tvgLottieParser.h tvgLottieParserHandler.cpp tvgLottieParserHandler.h tvgLottieProperty.h tvgLottieRenderPooler.h tvgMath.cpp tvgMath.h tvgPaint.cpp tvgPaint.h tvgPicture.cpp tvgPicture.h tvgRawLoader.cpp tvgRawLoader.h tvgRender.cpp tvgRender.h tvgSaveModule.h tvgSaver.cpp tvgScene.cpp tvgScene.h tvgShape.cpp tvgShape.h tvgStr.cpp tvgStr.h tvgSvgCssStyle.cpp tvgSvgCssStyle.h tvgSvgLoader.cpp tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.cpp tvgSvgPath.h tvgSvgSceneBuilder.cpp tvgSvgSceneBuilder.h tvgSvgUtil.cpp tvgSvgUtil.h tvgSwCanvas.cpp tvgSwCommon.h tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.cpp tvgSwRenderer.h tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgTaskScheduler.h tvgText.cpp tvgText.h tvgWgCanvas.cpp tvgXmlParser.cpp tvgXmlParser.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/thorvg/rapidjson/: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/thorvg/rapidjson/error/: en.h error.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/thorvg/rapidjson/internal/: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/thorvg/rapidjson/msinttypes/: inttypes.h stdint.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/tiny_ttf/: LICENSE.txt lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/libs/tjpgd/: LICENSE.txt lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h lvgl.h lvgl_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_lru_rb.c lv_cache_lru_rb.h lv_cache_private.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/osal/: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux_private.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h lv_font_manager_utils.c lv_font_manager_utils.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h README.md
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/observer/: lv_observer.c lv_observer.h lv_observer_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/test/: lv_test.h lv_test_display.c lv_test_display.h lv_test_helpers.c lv_test_helpers.h lv_test_indev.c lv_test_indev.h lv_test_indev_gesture.c lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.c lv_test_screenshot_compare.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/vg_lite_tvg/: vg_lite.h vg_lite_matrix.c vg_lite_tvg.cpp
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/xml/: lv_xml.c lv_xml.h lv_xml_base_types.c lv_xml_base_types.h lv_xml_component.c lv_xml_component.h lv_xml_component_private.h lv_xml_parser.c lv_xml_parser.h lv_xml_private.h lv_xml_style.c lv_xml_style.h lv_xml_utils.c lv_xml_utils.h lv_xml_widget.c lv_xml_widget.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/others/xml/parsers/: lv_xml_bar_parser.c lv_xml_bar_parser.h lv_xml_button_parser.c lv_xml_button_parser.h lv_xml_buttonmatrix_parser.c lv_xml_buttonmatrix_parser.h lv_xml_chart_parser.c lv_xml_chart_parser.h lv_xml_dropdown_parser.c lv_xml_dropdown_parser.h lv_xml_event_parser.c lv_xml_event_parser.h lv_xml_image_parser.c lv_xml_image_parser.h lv_xml_keyboard_parser.c lv_xml_keyboard_parser.h lv_xml_label_parser.c lv_xml_label_parser.h lv_xml_obj_parser.c lv_xml_obj_parser.h lv_xml_roller_parser.c lv_xml_roller_parser.h lv_xml_scale_parser.c lv_xml_scale_parser.h lv_xml_slider_parser.c lv_xml_slider_parser.h lv_xml_spangroup_parser.c lv_xml_spangroup_parser.h lv_xml_table_parser.c lv_xml_table_parser.h lv_xml_tabview_parser.c lv_xml_tabview_parser.h lv_xml_textarea_parser.c lv_xml_textarea_parser.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/builtin/: LICENSE_SPRINTF.txt LICENSE_TLSF.txt lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/micropython/: lv_mem_core_micropython.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/stdlib/uefi/: lv_mem_core_uefi.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/themes/default/: lv_theme_default.c lv_theme_default.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/list/: lv_list.c lv_list.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_style_properties.h lv_textarea_properties.c
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/spinner/: lv_spinner.c lv_spinner.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
    C:/Users/34118/Desktop/SD_LCD/Middlewares/lvgl_Library/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group LVGL_conf
    ../Middlewares/lvgl_Library/: lv_conf.h lvgl.h
  group LVGL_porting
    ../Middlewares/lvgl_Library/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
software components: CMSIS:CORE 4.3.0
